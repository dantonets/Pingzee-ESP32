## projects/PingZee-BT_WiFi/main/Kconfig
```kconfig
menu "PingZee BTWiFi Config"

config USE_SERIAL_CONSOLE
    bool "Use FreeRTOS CLI with serial console"

endmenu
```
